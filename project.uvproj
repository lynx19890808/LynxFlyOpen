# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;rt-thread\components\dfs;rt-thread\components\dfs\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\init;rt-thread\components\net\lwip\src;rt-thread\components\net\lwip\src\arch\include;rt-thread\components\net\lwip\src\include;rt-thread\components\net\lwip\src\include\ipv4;rt-thread\components\net\lwip\src\include\netif;rt-thread\include;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;wifi
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: cpuusage.c
  group LynxFly
    ./LynxFly/: TaskNotify.c TaskComm.c TaskControl.c TaskIMU.c
  group LynxFly_Control
    ./LynxFly_Control/: CFFRELS.c ControlFGR.c PIDNormal.c PPCFFRELS.c RELS.c STC_PP.c STC_PP_PID.c
  group Math
    ./Math/: LibMatrix.c LibMyMath.c
  group Drivers
    drivers/: board.c platform.c usart.c ext_sram.c stm32f4xx_it.c sdio_sd.c stm32f4xx_eth.c stm32f20x_40x_spi.c spi_flash_w25qxx.c
    ./drivers/: battery.c pwmRotor4.c module_hmc5883.c module_mpu6050.c module_ms5611.c stm32f4_i2c_dma.c module_ak8975.c module_sensor.c receiver.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Wifi
    wifi/: gspi_io.c ieee802_11.c if_gspi.c rt_wlan_dev.c wlan_11d.c wlan_cmd.c wlan_cmdresp.c wlan_fw.c wlan_join.c wlan_main.c wlan_rx.c wlan_scan.c wlan_tx.c wlan_utilites.c wlan_wext.c
  group Kernel
    rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.s
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group finsh
    rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Components
    rt-thread/components/init/: components_init.c
  group LwIP
    rt-thread/components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/src/arch/: sys_arch.c
    rt-thread/components/net/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    rt-thread/components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    rt-thread/components/net/lwip/src/netif/: etharp.c ethernetif.c slipif.c
